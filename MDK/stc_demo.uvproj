# Keil uVision project stc_demo.uvproj, settings and files
target stc_demo (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: stc_demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Device;..\Libraries
  group User
    ../User/: main.c
    ./: game_2048.c
  group Libraries
    ../Libraries/: delay.c sys.c timer.c
  group Device
    ../Device/: hc595.c led8.c matrix.c nixietube.c keyboard.c lcd1602.c hardiic.c oled.c dht11.c tftlcd.c gui.c touch.c ADC.c eeprom.c GPIO.c PWM.c ir.c pcf8563.c
